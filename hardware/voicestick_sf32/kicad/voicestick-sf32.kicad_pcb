# Repository 78/voicestick

File README.md:

# Voice Stick

English · [简体中文](README_ZH.md)

Voice Stick is a Bluetooth push-to-talk input device for macOS, Windows, and Linux. Build the VoiceStick C3 v1 from the published hardware files or use an M5Stack StickS3 or Magiclick 2P5.

Hold the front button on the StickS3 to record. When you release it, the macOS menu bar app sends the audio to ASR, shows the recognized text, and pastes the final result into the currently focused input field after a short confirmation countdown. By default it pastes text and presses Return; `auto_enter` can be disabled in settings.

## Project Layout

- `firmware/`: ESP-IDF firmware, with board support under `firmware/boards/`.
- [Build a VoiceStick C3 v1](hardware/README.md) — KiCad project, PCB fabrication files, printable enclosure and ESP32-C3 flashing instructions.
- `desktop/macos/`: Swift Package for the native macOS menu bar app.
- `desktop/windows/`: Windows desktop app workspace.
- `desktop/linux/`: GTK4 / libadwaita Linux desktop app.
- `docs/protocol.md`: BLE protocol between StickS3 and macOS.
- `docs/volcengine-asr.md`: trimmed Volcengine ASR notes used by the desktop client.
- `scripts/`: sprite slicing, palette tuning, and LVGL ARGB binary conversion helpers.

## Current Features

- StickS3 advertises as `VS-XXXX`, where `XXXX` is derived from the last two bytes of the eFuse MAC.
- The macOS app only connects to paired `VS-XXXX` devices and can keep multiple paired devices connected at once. The menu bar app lists every paired device and shows whether each one is connected or still scanning.
- The front button maps to the protocol `primary` role; it starts a recording session on press and ends it on release when the app has put the device in `ready`.
- The firmware reads 16 kHz mono PCM from the ES8311 microphone, encodes it as Opus, and sends it over BLE notifications.
- The macOS app supports VoiceStick Cloud and OpenAI Realtime (`gpt-live-transcribe`). It streams Ogg Opus to VoiceStick Cloud or decodes the device audio to 24 kHz PCM for OpenAI.
- During recognition, the macOS app shows a floating overlay and menu bar status. The firmware display stays in the thinking state after button release until the text is pasted or cancelled.
- The macOS menu bar's **Send Confirmation** options are immediate paste, a countdown of 1, 2, 3, 5, 10, or 15 seconds, and manual confirmation. The default countdown is 1 second.
- Pressing the front button during the countdown reveals the confirmation controls below the text in the same overlay. Click the text to edit it. Click **Send** or press the front button again to paste your edits. Click **Cancel** or press the side button to discard them.
- On StickS3 and MagiClick 2P5, shaking the device while the confirmation is paused also cancels the draft.
- Pressing the side button while idle restores the last recoverable input confirmation.
- Optional debug audio cache saves each valid recognition session as Ogg Opus, with the source device ID included in the file name when available.
- Firmware updates are checked from a signed-by-hash manifest on app launch, device connect/reconnect, and manual menu refresh. Updates are offered per connected device.
- The firmware screen shows pairing, ready, listening, thinking, pending confirmation, error, and battery states based on app-sent `ui_state` updates. It dims after 30 seconds of inactivity. On battery power it enters deep sleep after 5 minutes, or after 1 minute while no host is connected; while charging or USB powered it stays at the dimmed-screen stage. The front button wakes it from deep sleep.

## Hardware Target

- Board: M5Stack StickS3 / ESP32-S3-PICO-1-N8R8
- Front button: GPIO11, protocol `primary`, push-to-talk and deep-sleep wake
- Side button: GPIO12, protocol `secondary`, cancel or restore the last input confirmation
- PMIC IRQ: GPIO13
- Audio codec: ES8311 over I2S, 16 kHz / 16 bit / mono
- Display: 135 x 240 ST7789P3 portrait screen
- LCD backlight: GPIO38 PWM

Main pin definitions live in `firmware/boards/m5stack_stick_s3/components/stick_s3_board/include/stick_s3_board.h`.

Magiclick 2P5 (`magiclick_2p5`) uses an ESP32-S3 with an ES8311 microphone and a 128 × 128 LCD. The firmware reads the PCB revision strap to select the GC9107 or ST7735 panel. The center voice button wakes the device from deep sleep and opens BLE pairing when disconnected. The left button cancels on a short press and doubles as BOOT during reset.

VoiceStick C3 v1 (`hardware/voicestick_c3`, board `voicestick_c3`):

- ESP32-C3 + 8 MB flash, 32.768 kHz crystal for the RTC and BLE sleep clock
- Keys: main GPIO4 `primary` (deep-sleep wake), cancel GPIO9 `secondary`, prev GPIO8 `prev`, next GPIO21 `next`
- Audio: SD18OB371 PDM mic, raw I2S PDM at 1.536 MHz, CIC3 decimation in software to 16 kHz
- Status: one WS2812B LED on GPIO20 instead of a screen
- Power: TP4054 charger (CHRG on GPIO10), USB sense GPIO5 (deep-sleep wake), battery ADC GPIO3, LED and mic rail switched by GPIO2

Pin definitions live in `firmware/boards/voicestick_c3/components/board/voicestick_c3.h`.

## Interaction Model

| State | Front button | Side button |
| --- | --- | --- |
| Unpaired / disconnected | No recording; screen shows `VS-XXXX` | No effective action |
| Connected idle | Hold to record | Restore last input confirmation |
| Recording | Release to finish recording | Does not cancel the active recording |
| Thinking / finalizing | New recording is ignored | Cancel the in-progress recognition |
| Pending confirmation countdown | Pause auto-paste and keep pending confirmation | Cancel pending text |
| Manual pending confirmation | Confirm paste | Cancel pending text |

The firmware reports `button_down` and `button_up` with a button ID and device
timestamp in both voice and game modes. VoiceStick 0.5.0 requires firmware
0.5.0 for input. Older devices stay available for firmware updates through the
device menu.

By default the paste flow presses Return after paste. Disable `Press Return after paste` in settings, or set `auto_enter = false` in the config file, to paste without sending Return.

## Audio Path

```text
StickS3 mic -> ES8311/I2S PCM -> Opus -> BLE -> macOS -> Ogg Opus -> ASR -> paste
```

VoiceStick Cloud receives Ogg Opus directly. The macOS client decodes Opus to PCM for OpenAI Realtime.

## BLE Protocol Summary

GATT service:

```text
8f2f0b84-6e6f-4b23-88f7-3a3ceafc5100
```

Characteristics:

| Name | UUID | Direction | Properties |
| --- | --- | --- | --- |
| `audio_tx` | `8f2f0b84-6e6f-4b23-88f7-3a3ceafc5101` | StickS3 -> Mac | notify |
| `state_tx` | `8f2f0b84-6e6f-4b23-88f7-3a3ceafc5102` | StickS3 -> Mac | notify |
| `control_rx` | `8f2f0b84-6e6f-4b23-88f7-3a3ceafc5103` | Mac -> StickS3 | write without response |

See `docs/protocol.md` for the full frame format.

## Firmware Build

The firmware targets ESP-IDF release-v6.1. Activate it first, for example with the EIM-installed script:

```sh
source ~/.espressif/tools/activate_idf_release-v6.1.sh
```

Each board is a directory under `firmware/boards/<board>/` with `board.cmake` (chip), `sdkconfig.defaults` (applied on top of `firmware/sdkconfig.defaults`) and a `board` component implementing `firmware/components/board_api`. The board selects the chip, so `idf.py set-target` is not used. Give every board its own build directory:

```sh
cd firmware
idf.py build                                         # M5Stack StickS3 (default)
idf.py -B build-c3 -DBOARD=voicestick_c3 build       # VoiceStick C3 v1
idf.py -B build-magiclick-2p5 -DBOARD=magiclick_2p5 build
```

Flash and monitor:

```sh
idf.py -p /dev/cu.usbmodemXXXX flash monitor
idf.py -B build-c3 -p /dev/cu.usbmodemXXXX flash monitor
idf.py -B build-magiclick-2p5 -p /dev/cu.usbmodemXXXX flash monitor
```

Board-specific options (for example the C3 microphone clock, slot and gain) are under `idf.py -B build-c3 menuconfig`.

The firmware uses an OTA partition table with two 3 MB app slots plus a reserved 1984 KB `storage` partition. Devices flashed with the old single-app table need one USB flash to install the new partition table before BLE OTA updates can be used:

```sh
idf.py -p /dev/cu.usbmodemXXXX erase-flash flash monitor
```

Firmware dependencies are declared through the ESP-IDF component manager:

- `espressif/button`
- `espressif/cjson`
- `78/esp-opus`
- StickS3 and Magiclick 2P5 use `espressif/esp_codec_dev` and `lvgl/lvgl`
- StickS3 uses `espressif/bmi270` for shake cancellation
- Magiclick 2P5 also uses `espressif/esp_lcd_gc9a01` for the GC9107 panel
- Magiclick 2P5 and VoiceStick C3 use `espressif/adc_battery_estimation` for battery percentage
- VoiceStick C3: `espressif/led_strip`

## macOS Desktop Build

The desktop app is a Swift Package targeting macOS 12 or newer.

```sh
cd desktop/macos
swift build
```

Run it:

```sh
swift run VoiceStickApp
```

The app is a menu bar accessory app and requests Bluetooth permission. Text insertion uses simulated `Command-V` plus optional Return. If macOS blocks the keyboard events, grant Accessibility permission to the running terminal or app in System Settings.

For a distributable macOS release with Sparkle updates:

```sh
SPARKLE_PUBLIC_ED_KEY="..." scripts/build-macos.sh --release
scripts/make-dmg.sh
```

The build script writes `build/VoiceStick-<version>.app`, `build/VoiceStick-<version>.zip`, and a Sparkle signature file. Upload the DMG and ZIP to GitHub Releases, then update `website/appcast.xml` for the GitHub Pages update feed.

For a distributable Windows release with WinSparkle updates, the MSI is the update package. The Windows signing certificate is expected to live on the local signing machine, such as a USB hardware key:

```bat
scripts\build-msi.bat
```

The script signs `VoiceStick.exe`, `WinSparkle.dll`, and `VoiceStick_<version>.msi` locally. Upload that MSI to the matching GitHub Release, then manually run the `Deploy Website to GitHub Pages` workflow so the shared appcast points Windows clients at the Release asset URL.

## Linux Desktop Build

The Linux app is GTK4 + libadwaita. On GNOME, install `gnome-shell-extension-appindicator` (Debian UUID `ubuntu-appindicators@ubuntu.com`) and log in again so the top-bar icon can appear.

```sh
sudo apt install cmake ninja-build g++ pkg-config \
  libgtk-4-dev libadwaita-1-dev libsoup-3.0-dev \
  libglib2.0-dev libatspi2.0-dev libssl-dev \
  gnome-shell-extension-appindicator
cmake -S desktop/linux -B desktop/linux/build -G Ninja
cmake --build desktop/linux/build
desktop/linux/build/VoiceStick
```

Config is `~/.config/voicestick/config.toml`. Text is copied with GTK, then VoiceStick tries AT-SPI insert. If that fails, it uses the GNOME Remote Desktop portal to inject Ctrl+V. See `desktop/linux/README.md`.

GitHub Actions can do the macOS and firmware release path automatically when a `v<version>` tag is pushed. The tag must match `VERSION`, for example `VERSION=0.2.1` pairs with `v0.2.1`. The release workflow publishes the macOS DMG/ZIP/signature and firmware assets to GitHub Releases, then deploys the website/appcast to GitHub Pages. The Windows MSI is uploaded afterward from the local signing machine. See `docs/release.md` for the full release process, including the Windows-first and Windows-afterward flows.

The same release workflow builds StickS3, VoiceStick C3, and MagiClick 2P5 firmware with ESP-IDF release-v6.1 and uploads firmware artifacts to Aliyun OSS:

| File | Use |
| --- | --- |
| `voicestick-firmware-<board>-ota-<version>.bin` | Application image for OTA updates |
| `voicestick-firmware-<board>-merged-<version>.bin` | Browser/USB flashing image written at offset `0x0` |
| `manifest.json` | Latest firmware metadata for the app and website |

Image filenames use `sticks3`, `c3`, or `magiclick_2p5` for `<board>`. Each board has a versioned manifest and a stable update URL.

```text
voicestick/firmwares/<version>/manifest.json
voicestick/firmwares/latest/manifest.json
voicestick/firmwares/voicestick_c3/<version>/manifest.json
voicestick/firmwares/voicestick_c3/latest/manifest.json
voicestick/firmwares/magiclick_2p5/<version>/manifest.json
voicestick/firmwares/magiclick_2p5/latest/manifest.json
```

The macOS app checks the stable latest manifest URL on app launch, on device connect/reconnect, and at most once every 24 hours while running. The menu also has `Check for Firmware Updates` for a manual refresh. If a connected device reports an older `firmware_version` than the manifest version, its device submenu shows `Update to <version>...`. The app downloads the manifest `ota_url` and verifies `ota_size` plus `ota_sha256` before starting BLE OTA.

Configure these GitHub secrets before running the release workflow:

| Name | Description |
| --- | --- |
| `ALIYUN_OSS_ACCESS_KEY_ID` | OSS upload access key ID |
| `ALIYUN_OSS_ACCESS_KEY_SECRET` | OSS upload access key secret |
| `ALIYUN_OSS_ENDPOINT` | OSS endpoint, for example `https://oss-cn-hangzhou.aliyuncs.com` |
| `ALIYUN_OSS_BUCKET` | OSS bucket name |

Set the repository variable `ALIYUN_OSS_PUBLIC_BASE_URL` to the public OSS base URL, for example `https://xiaozhi-voice-assistant.oss-cn-shenzhen.aliyuncs.com`. Optional variable `ALIYUN_OSS_PREFIX` controls the OSS object prefix and defaults to `voicestick/firmwares`.

## Local Config

Config path:

```text
macOS:  ~/Library/Application Support/VoiceStick/config.toml
Linux:  ~/.config/voicestick/config.toml
```

Create it from the example:

```sh
mkdir -p "$HOME/Library/Application Support/VoiceStick"
cp desktop/macos/Config/config.example.toml "$HOME/Library/Application Support/VoiceStick/config.toml"
```

Example:

```toml
asr_provider = "voicestick_cloud"
voicestick_api_key = ""
voicestick_cloud_url = "wss://api.xiaozhi.me/voicestick/asr/"
openai_api_key = ""
interaction_mode = "hold_to_talk"
asr_hotwords = "小智,VoiceStick"
paired_device_ids = ""
device_theme_colors = ""
device_overlay_positions = ""
auto_enter = true
debug_audio_cache = false
# debug_audio_dir = "~/Library/Application Support/VoiceStick/DebugAudio"

[output]
target = "focused_app"
transform = "original"
translation_target = "en"

# Optional per-device subtitle translation:
# [device.C3D8.output]
# transform = "translate"
# translation_target = "en"
```

Fields:

| Field | Description |
| --- | --- |
| `asr_provider` | `voicestick_cloud` or `openai` on macOS |
| `openai_api_key` | Shared key for OpenAI Realtime ASR, polishing, and translation on macOS |
| `voicestick_api_key` | VoiceStick Cloud relay API key, sent as `X-Api-Key` |
| `voicestick_cloud_url` | Cloud relay WebSocket URL |
| `llm_base_url`, `llm_api_key`, `llm_model` | Optional text API fallback for legacy self-hosted Cloud relays |
| `interaction_mode` | Front button interaction: `hold_to_talk` or `click_to_talk` |
| `asr_hotwords` | Comma-separated ASR hotwords, also used as terminology hints for polishing and translation |
| `paired_device_ids` | Comma-separated 4-digit hex IDs, for example `C3D8,09AF` |
| `device_theme_colors` | Optional per-device overlay colors, for example `C3D8:pink,09AF:green` |
| `device_overlay_positions` | Optional per-device overlay positions, for example `C3D8:top_left,09AF:bottom_right` |
| `auto_enter` | Whether to press Return after paste |
| `debug_audio_cache` | Whether to save debug Ogg Opus files |
| `debug_audio_dir` | Debug audio output directory |
| `[output].target` | `focused_app` or `subtitle` |
| `[output].transform` | `original`, `polish` (macOS), or `translate` |
| `[output].translation_target` | Target language code for LLM translation, for example `en` or `zh-Hans` |
| `[device.<id>.output]` | Optional per-device override for text transform and translation target |

On macOS, choose **Text Output → Refine** in the device menu to correct clear speech recognition errors and clean up dictated text in its original language. With **OpenAI Realtime** selected, refinement and translation automatically use GPT-6 Luna with the same OpenAI API key.
With **VoiceStick Cloud** selected, Refine and translation use the Cloud key and return over the same connection as the transcript.

Older macOS configs set to `volcengine` open with VoiceStick Cloud selected. Use an existing Cloud key or **Apply Trial** in Settings.

Do not commit API keys.

## Pairing a New Computer

VoiceStick reconnects automatically to its paired computer, including after a firmware update. Use these steps when pairing for the first time or switching to a different computer.

1. Turn on the VoiceStick and start the macOS app on the computer you want to pair.
2. A VoiceStick that has never been paired accepts pairing for 60 seconds after it turns on or wakes. If you are switching computers, disconnect the VoiceStick from the old computer, then press the main voice button once to open the same window. The C3 flashes blue during the pairing window.
3. Open `Pair Device...` from the menu bar, select the matching `VS-XXXX`, and click `Pair`.
4. Confirm the Bluetooth connection in macOS if prompted. The app reconnects automatically after pairing.

Each VoiceStick remembers one computer. The macOS app can connect to multiple VoiceSticks. With older firmware, select the device directly from the list.

## Debug Audio

Enable:

```toml
debug_audio_cache = true
```

Default output directory:

```text
~/Library/Application Support/VoiceStick/DebugAudio
```

Each valid recognition session is saved as a playable Ogg Opus file. Recordings shorter than 0.5 seconds are discarded by the desktop app and are not sent to ASR.

## License

This project is licensed under the [MIT License](LICENSE).

## KiCad design hardware/voicestick_sf32/kicad/voicestick-sf32.kicad_pcb

File hardware/README.md:

# Build a VoiceStick C3 v1

English · [简体中文](README_ZH.md)

VoiceStick C3 v1 is the first public hardware design for the Bluetooth talk button. It pairs an ESP32-C3 and a PDM microphone with a main key, three side keys and an RGB status LED on a 50 × 30 mm board.

Each board has its own directory under `hardware/`, named after the matching firmware board. The current C3 design is [voicestick_c3](voicestick_c3/README.md), hardware revision v1.

## v1 release files

For fabrication and printing, extract `voicestick-c3-v1-build-files.zip`. For a populated board in KiCad’s 3D viewer or a full board STEP export, extract `voicestick-c3-v1-component-models.zip` into `hardware/voicestick_c3/` in the source checkout. This places seven STEP files in `kicad/3dmodels/`. [VoiceStick C3 v1 release](https://github.com/78/voicestick/releases/tag/hw-voicestick-c3-v1)

1. **Order the PCB.** In the build archive, open `fab/`. Use the four-layer, 1.0 mm stack-up in the [fabrication guide](voicestick_c3/fab/README.md). Upload the Gerber ZIP, BOM and placement file. Leave C25 and C26 unpopulated and check component rotations in the assembly preview.
2. **Print the enclosure.** Start with the tolerance coupon. The STL parts (`enclosure/out/stl/`) are oriented for printing. The individual STEP solids (`enclosure/out/step/`) can be edited in CAD or opened in a STEP-capable slicer. Set the print face using the [printing and assembly guide](voicestick_c3/enclosure/README.md). The complete assembly STEP (`enclosure/out/voicestick-c3-v1-assembly.step`) shows the PCB, enclosure and battery in position.
3. **Power up and flash.** Start the USB power checks with the battery disconnected. Use a protected, two-wire 602025 250 mAh cell. On the JST SH 1.0 mm connector J2, pin 1 is battery positive and pin 2 is ground. Activate ESP-IDF release-v6.1, then run the following from the repository root, substituting your serial port. The release binaries target StickS3. Build the C3 image with `voicestick_c3`.

```sh
cd firmware
idf.py -B build-c3 -DBOARD=voicestick_c3 build
idf.py -B build-c3 -p /dev/cu.usbmodemXXXX flash monitor
```

**Verification.** Review the [ERC](voicestick_c3/kicad/erc.rpt), [DRC](voicestick_c3/kicad/drc.rpt) and [enclosure clearance report](voicestick_c3/enclosure/out/enclosure-report.json). Microphone noise, antenna matching with the case fitted and deep-sleep current still need measurements on assembled hardware. See the [first-board checks](voicestick_c3/README.md#first-board-checks).

For modifications, start with the [design notes and GPIO map](voicestick_c3/README.md), schematic PDF (`kicad/voicestick-c3-v1-schematic.pdf`) or [KiCad project](voicestick_c3/kicad/voicestick-c3-v1.kicad_pro).

Parts:
C1, C3, C4: 4.7uF 16V; C_0603_1608Metric; MPN CL10A475KO8NNNC; LCSC C19666
C2: 10uF 25V; C_0805_2012Metric
C5, C6, C8, C9: 100nF; C_0402_1005Metric
C7, C24: 1uF; C_0402_1005Metric
D1: PESD5V0S1BA; D_SOD-323; MPN PESD5V0S1BA
D2: WS2812B-2020-V6; LED_WS2812B-2020_PLCC4_2.0x2.0mm; MPN Worldsemi WS2812B-2020-V6; LCSC C52917434
D3: RED; LED_LiteOn_LTST-S270; MPN Lite-On LTST-S270KRKT; LCSC C125114
D4: BAT54WS; D_SOD-323; MPN BAT54WS
J1: TYPE-C-31-M-12; USB_C_Receptacle_HRO_TYPE-C-31-M-12_BoardEdge; MPN HRO TYPE-C-31-M-12; LCSC C165948
J2: BAT / MX1.25; SHOUHAN_1.25-2P_C393945; MPN SHOU HAN 1.25-2P; LCSC C393945
R1, R2: 5.1k; R_0402_1005Metric; MPN 0402WGF5101TCE; LCSC C25905
R3: 18k 1%; R_0402_1005Metric; MPN 0402WGF1802TCE; LCSC C25762
R4, R13: 3.3k 1%; R_0402_1005Metric; MPN 0402WGF3301TCE; LCSC C25890
R5, R11, R17: 100k; R_0402_1005Metric
R6: 120k; R_0402_1005Metric
R7: 2.2k; R_0402_1005Metric
R8, R9: 10k; R_0402_1005Metric
R10, R12: 33R; R_0402_1005Metric
R14: 10k 1%; R_0402_1005Metric
R15, R16: 100R; R_0402_1005Metric
SW1: PUSH TO TALK; CPG151101D05; MPN Kailh CPG151101D05; LCSC C49234236
SW2: PREV; Alps_SKRTLBE010; MPN Alps SKRTLBE010; LCSC C127481
SW3: NEXT; Alps_SKRTLBE010; MPN Alps SKRTLBE010; LCSC C127481
SW4: CANCEL / RESET; Alps_SKRTLBE010; MPN Alps SKRTLBE010; LCSC C127481
TH1: 10k B25/85=3435K; R_0603_1608Metric
TP1: DBG_TX_CLK; TestPoint_Pad_D1.5mm
TP2: DBG_RX_DIO; TestPoint_Pad_D1.5mm
TP3: GND; TestPoint_Pad_D1.5mm
TP4: VOUT2_3V3; TestPoint_Pad_D1.5mm
TP5: SYS; TestPoint_Pad_D1.5mm
TP6: BAT_P; TestPoint_Pad_D1.5mm
U1: SF32LB52-MOD-1-N16R8; COMM-SMD_L27.9-W18.0-P1.10_SF32LB52-MOD-1-N16R8; MPN LC-OPEN-SF32LB52-MOD-N16R8; LCSC C42924267
U2: BQ25185DLHR; Texas_DLH0010A_WSON-10-1EP_2.2x2mm_P0.4mm_EP0.9x1.5mm; MPN BQ25185DLHR
U3: SN74LV1T34DBVR; SOT-23-5
U5: ZTS6538SE; MIC-SMD_6P-L2.8-W1.9-BL; LCSC C5155190
U6: USBLC6-2SC6; SOT-23-6; MPN USBLC6-2SC6; LCSC C7519

Connections:
BAT_P: C3.1, C6.1, D1.1 (A1), J2.1, R13.1, TP6.1, U1.61 (VBATS), U2.2 (BAT)
CANCEL_RST: R14.1, SW4.2, U1.14 (PA34)
CC1: J1.A5 (CC1), R1.1
CC2: J1.B5 (CC2), R2.1
CHARGE_N: D4.2 (A), R8.2, U1.8 (PA40)
CHG_A: D3.2 (A), R7.2
CHG_DISABLE: R17.1, U1.31 (PA11), U2.4 (~CE)
DBG_RX_DIO: R16.2, TP2.1
DBG_TX_CLK: R15.2, TP1.1
FAULT_N: R9.2, U1.9 (PA39), U2.9 (STAT1)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C24.2, D1.2 (A2), D2.2 (VSS), J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.SH (SHIELD), J2.2, R1.2, R2.2, R3.2, R4.2, R6.2, R11.2, R14.2, R17.2, SW1.2, SW2.2, SW3.2, TH1.2, TP3.1, U1.1 (GND), U1.26 (GND), U1.35 (GND), U1.48 (GND), U1.49 (GND), U1.50 (GND), U1.51 (GND), U1.52 (GND), U1.53 (GND), U1.54 (GND), U1.55 (GND), U1.56 (GND), U1.57 (GND), U1.58 (GND), U1.59 (GND), U1.60 (GND), U2.5 (GND), U2.11 (EP), U3.3 (GND), U5.1 (GND), U5.2 (SEL), U5.3 (GND), U6.2 (GND)
ISET: R4.1, U2.8 (ISET)
KEY_FEED: R13.2, SW4.1
NEXT_N: SW3.1, U1.7 (PA41)
PDM_CLK: R10.2, U5.4 (CLK)
PDM_CLK_SRC: R10.1, U1.40 (PA07)
PDM_DAT: U1.39 (PA08), U5.5 (DATA)
PREV_N: SW2.1, U1.4 (PA42)
PTT_N: SW1.1, U1.3 (PA43)
RGB_BUF: R12.1, U3.4 (Y)
RGB_DATA: R11.1, U1.16 (PA32), U3.2 (A)
RGB_DIN: D2.3 (DIN), R12.2
STAT2_N: D3.1 (K), D4.1 (K), U2.3 (STAT2)
SYS: C2.1, C4.1, C5.1, C8.1, C9.1, D2.4 (VDD), TP5.1, U1.27 (VSYS), U2.1 (SYS), U3.5 (VCC)
TS: TH1.1, U2.6 (TS/MR)
UART_RX_SWDIO: R16.1, U1.30 (PA18)
UART_TX_SWCLK: R15.1, U1.29 (PA19)
USB_DN: J1.A7 (D-), J1.B7 (D-), U1.12 (PA36), U6.3 (I/O2), U6.4 (I/O2)
USB_DP: J1.A6 (D+), J1.B6 (D+), U1.13 (PA35), U6.1 (I/O1), U6.6 (I/O1)
VBUS: C1.1, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), R5.1, R7.1, U2.10 (IN), U6.5 (VBUS)
VBUS_DET: R5.2, R6.1, U1.2 (PA44)
VOUT2_3V3: C7.1, C24.1, R8.1, R9.1, TP4.1, U1.17 (VDD33_VOUT2), U5.6 (VDD)
VSET: R3.1, U2.7 (ILIM/VSET)

Notes on the sheet:
HARDWARE / A0
VBUS 分压
ZTS6538SE 顶部进音，SEL 接地。
49 个器件 / 33 个网络 / 10 个模块
系统与电池输出
同名网络相连 · 实心点表示连接 · × 表示未接 · GND 为公共地
SF32LB52 / 电源去耦
思澈主控模组
指示灯 / 主控反馈
电池与充电
硬件复位
按下为低电平，由主控开启内部上拉。
接地焊盘合并显示。
TP5 测系统电源，TP6 测电池保护板输出。
按键输入
D4 隔离 USB 供电的充电指示灯。
接口与 CC 下拉
U6 两侧同名 I/O 焊盘分别接入 D+、D-。
U2：充满 4.20 V，输入限流 500 mA，标称快充 90.9 mA。
TH1 贴近电芯。J2 接 250 mAh 带保护板电池，1 脚为正。
SW1 至 SW4 · 按键
充电状态
取消与复位
CHARGE_N 至 PA40，FAULT_N 至 PA39。
U1.40 输出时钟，U1.39 采入数据。
USB 与供电 01–04 / 录音 04–05 / 灯与按键 06–08 / 调试与测量 09–10
数字麦克风
电池低于 3.4 V 时熄灭灯珠，待机时数据输入保持低电平。
USB_DP / USB_DN 至 U1.13 / U1.12。
先开启 VOUT2，再启动 PDM。
U1.7 / PA41 下一项
装电池时，短按取消，长按约 10 秒复位。
至 U1.14 / PA34，按下为高电平。
TP1 / TP2 接 U1.29 / U1.30，复用 UART 与 SWD。
充电参数
录音与翻页
来自 U2.1
RGB 指示灯
TP3 至 TP6
UART / SWD

Board: 2 copper layers, 58.0 x 25.7 mm, 49 parts (6 on the bottom side), 33 nets.
